Commit message: A new hope

File: robot_arm_urdf/urdf/robot_arm_urdf.urdf (robot description, URDF)
Before this commit: robot robot_arm_urdf, 9 links, 8 joints
Joints:
- joint base_joint: origin xyz=1.3 0 0.764991 rpy=0 0 3.142 -> xyz=0 0.2 0.9 rpy=0 0 3.142
